# Keil uVision project edicfwdecompressor.uvprojx, settings and files
target EDIC (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: edicfwdecompressor +hex
  AfterMake: fromelf --bin Objects/edicfwdecompressor.axf -o edicfwdecompressor.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  memory RVCT1: ROM 0x10000000 size 0x4000
  memory RVCT2: ROM 0x30000000 size 0x40000
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x10004000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\edicfwdecompressor.sct
  group Main
    ./: startup.sx main.c edic_defs.h sys.c sys.h code.h
  group LZMA
    ./: lzma.c lzma.h
